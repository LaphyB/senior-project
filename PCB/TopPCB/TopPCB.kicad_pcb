# Repository LaphyB/senior-project

File README.md:

# senior-project
Adaptive One-Handed Gyro Controller

## KiCad design PCB/Schematics/2-axis-joystick-breakout-board-with-mounting-holes-master/joystick.kicad_pcb

Board: 16 copper layers, 38.1 x 38.1 mm, 7 parts (0 on the bottom side), 5 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
JP1: 1X05
U1: JOYSTICKPTH; JOYSTICK
U$1: ADAFRUIT200MIL

Connections:
unnamed: JP1.5, U1.H1, U1.V1
unnamed: JP1.1, U1.B2A, U1.H3, U1.V3
unnamed: JP1.4, U1.V2
unnamed: JP1.3, U1.H2
unnamed: JP1.2, U1.B1A

## KiCad design PCB/Schematics/Adafruit-PowerBoost-1000C-master/Adafruit PowerBoost 1000C Rev B.kicad_pcb

Board: 2 copper layers, 36.1 x 22.9 mm, 47 parts (2 on the bottom side), 23 nets.

Parts:
B1: JST 2-PH; JSTPH2
C1, C7, C8: 10uF; 0805-NO
C2: 2.2uF; 0805-NO
C4: 0.1uF; 0805_10MGAP
C6: 100uF; C1210
CHRG/LBO0: ORANGE; CHIPLED_0805_NOOUTLINE
CN1: USBA_FEMALE; USB_HOST-PTH
CN4: MicroUSB; 4UCONN_20329
DONE0: GREEN; CHIPLED_0805_NOOUTLINE
FID1, FID2, FID3: FIDUCIAL""; FIDUCIAL_1MM
JP2: 1X08_ROUND
L1: 6.8uH; INDUCTOR_5X5MM_TDK_VLC5045
LED1: RED; CHIPLED_0805_NOOUTLINE
LED2: BLUE; CHIPLED_0805_NOOUTLINE
R1: 1.87M; _0805MP
R2: 340K; _0805MP
R3: 1.87M; 0805-NO
R4, R13: 200K; 0805-NO
R5, R8, R14, R20: 1K; 0805-NO
R6: 270K; 0805-NO
R7, R17: 100K; 0805-NO
R9: 43K; 0805-NO
R10: 49.9K; 0805-NO
R11: 75K 1%; 0805-NO
R12: 49.9K 1%; 0805-NO
R16: 1.0K; 0805-NO
T1: MMUN2133LT1G; SC59-BEC
THERM0: 15K; 0805-NO
U1: TPS61090RSAR; PVQFN-16
U2: MCP73871; QFN20_4MM
U$10, U$11: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$12: PCBFEAT-REV-040
U$25: SYMBOL_PLUS
U$26: SYMBOL_MINUS
U$28: ADAFRUIT_5MM
U$45: ADAFRUIT_3.5MM
X1: TERMBLOCK_1X2-3.5MM

Connections:
5.0V: C2.1, C6.1, CN1.VBUS, JP2.8, R3.2, R5.1, R9.2, R11.2, U1.1, U1.15, U1.16, X1.2
D+: CN1.D+, R11.1, R12.1
D-: CN1.D-, R9.1, R10.1
ENABLE: JP2.4, R13.2, U1.11
GND: B1.1, C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, CN1.GND, CN4.BASE@1, CN4.BASE@2, CN4.GND, CN4.SPRT@1, CN4.SPRT@2, CN4.SPRT@3, CN4.SPRT@4, JP2.5, JP2.7, LED1.C, LED2.C, R2.1, R4.1, R7.2, R10.2, R12.2, R16.1, R17.1, THERM0.1, U1.5, U1.6, U1.7, U1.10, U1.13, U1.P$18, U1.P$19, U1.P$20, U1.P$21, U1.P$22, U1.THERMAL, U2.P$10, U2.P$11, U2.P$21, X1.1
LBO: JP2.6, T1.B, U1.12
unnamed: L1.P$2, U1.3, U1.4
unnamed: LED1.A, R20.1
unnamed: R1.1, R2.2, U1.9
unnamed: LED2.A, R5.2
unnamed: R3.1, R4.2, U1.14
unnamed: R20.2, T1.C
unnamed: R6.1, R7.1, U2.P$2
unnamed: DONE0.C, R14.2
unnamed: R14.1, U2.P$7
unnamed: THERM0.2, U2.P$5
unnamed: R8.1, U2.P$8
unnamed: CHRG/LBO0.C, R8.2
unnamed: R17.2, U2.P$12
unnamed: R16.2, U2.P$13
VBAT: C1.1, C4.1, JP2.3, L1.P$1, R1.2, R13.1, T1.E, U1.8, U2.P$1, U2.P$20
VBUS: C8.1, CHRG/LBO0.A, CN4.VBUS, DONE0.A, JP2.1, R6.2, U2.P$3, U2.P$4, U2.P$9, U2.P$17, U2.P$18, U2.P$19
VLIPO: B1.2, C7.1, JP2.2, U2.P$14, U2.P$15, U2.P$16

## Commit log

2026-06-11 Bringing Senior Project from Gitlab to Github
2026-06-11 Updated Code and Report
2026-06-11 Updated PCB, 3d Models, and some Code to fix mistakes.
2026-06-14 Updated Testing Documentation and Code
